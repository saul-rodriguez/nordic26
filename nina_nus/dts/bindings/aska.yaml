## nina_nus/dts/bindings/aska.yaml
```yaml
description: ASKA Multichannel NMES  

compatible: "aska,kth"

include: [base.yaml, sensor-device.yaml, spi-device.yaml]
```
